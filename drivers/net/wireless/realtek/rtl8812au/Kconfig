## drivers/net/wireless/realtek/rtl8812au/Kconfig
```kconfig
config RTL8812AU_8821AU
	tristate "Realtek 8812 USB WiFi"
	depends on USB
	help
	  Help message of RTL8812AU
```
